# Keil uVision project RavenOSV2Demo.uvprojx, settings and files
target RavenOS Demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: CU_SYSC4906.LabF14_DFP.1.0.7
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RavenOS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM TM4C123GH6PM
  c include: .\RTE\RTOS\Include;.\RTE\Application\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group RavenOS Source
    ./RTE/RTOS/Source/: retarget.c peripherals.c trace.c kernel.c threads.c semaphores.c threadIdle.c protectedTrace.c
  group Application
    ./RTE/Application/source/: main.c sem1.c thread1.c thread3.c
    ./: thread2.c thread4.c sem2.c sem3.c thread5.c sem4.c timers.c timers.h PCP_resource1.c PCP_resource2.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, CMSIS Driver:USART:TM4C123GH6PM 2.01
